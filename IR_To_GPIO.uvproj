# Keil uVision project IR_To_GPIO.uvproj, settings and files
target Target 1 (MCS-51)
  device: W78E58 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0-0x7FFF) CLOCK(40000000)
  output: IR_To_GPIO +hex
  c flags: Optimize=8 SizeSpeed=1
  group Including Files
    ./: MEMALLOC.H STARTUP.A51 GrobalDefine.inc GrobalDefine.h ICE65xx.asm Decode.h automata_common.h buffer.h debug.h MAIN.h XFR.h KeyCodeTable.h int.h
  group Source Files
    ./: MAIN.C Decode.c buffer.c automata_rc6.c automata_nec.c int.c KeyCodeTable.c
